

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 1.717 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.25877 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 21.333 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 102.804 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 565.378 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2733.26 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA56 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 9.779 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.2294 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 186.091 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 898.056 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 1.331 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.40211 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.088 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.42568 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 99.5056 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 485.19 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 1.221 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.87301 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 10.932 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.7753 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 6.172 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.8797 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 20.349 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 98.0711 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 422.883 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 2051.46 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 5.41839 LAYER VIA67 ;
  END SI[0]
  PIN SO[3] 
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 13.652 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 65.8585 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 133.289 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 638.895 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.48505 LAYER VIA34 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 1.371 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.59451 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 11.479 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.4064 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 36.234 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 174.478 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNADIFFAREA 0.537 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 10.017 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 48.3742 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 72.6847 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 352.316 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 2.55725 LAYER VIA67 ;
  END SO[2]
  PIN SO[1] 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.047 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.84607 LAYER METAL3 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 4.984 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.1654 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.524 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 8.14 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.3458 LAYER METAL4 ;
  END SO[0]
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.141 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.67821 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.794 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.82154 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.720778 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 3.54987 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.241 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.15921 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.714 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.62674 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.547734 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2.78035 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 11.366 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 54.6705 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.334 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.60894 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 36.8293 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 180.902 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END RST_N
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 7.311 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1659 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 13.798 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 66.5608 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.29 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.4473 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4602 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 21.214 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 103.495 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.928523 LAYER VIA45 ;
  END UART_RX_IN
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.862 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.14862 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.74298 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 3.65666 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 1.371 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.59451 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.304 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2746 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 66.4353 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 319.096 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 2.009 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.66329 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 10.162 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 49.264 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.846 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 15.9193 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 76.3 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.477573 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL4 ;
    ANTENNAGATEAREA 1.846 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 16.0645 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 77.1025 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 0.516685 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 13.962 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 67.3496 LAYER METAL5 ;
    ANTENNAGATEAREA 1.9669 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 35.9384 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 176.592 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.09016 LAYER VIA56 ;
  END test_mode
  PIN SE 
    ANTENNAPARTIALMETALAREA 1.563 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.51803 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 4.696 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7802 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 29.3994 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 142.828 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.617094 LAYER VIA34 ;
  END SE
  PIN UART_TX_OUT 
    ANTENNAPARTIALMETALAREA 3.156 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.1804 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.254 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.41414 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.524 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 2.391 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6931 LAYER METAL4 ;
  END UART_TX_OUT
  PIN parity_error 
    ANTENNAPARTIALMETALAREA 4.447 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.3901 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 14.454 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 69.7161 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.6038 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.09235 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNADIFFAREA 0.6 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 15.976 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 94.3956 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.273 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 299.064 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 1517.92 LAYER METAL7 ;
  END parity_error
  PIN framing_error 
    ANTENNADIFFAREA 0.6 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 11.344 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.9494 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3068 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 118.438 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 572.145 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.81104 LAYER VIA34 ;
  END framing_error
END SYS_TOP

END LIBRARY
